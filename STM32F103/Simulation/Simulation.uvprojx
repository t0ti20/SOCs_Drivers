# Keil uVision project Simulation.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\STM32F103C8\MCAL\RCC;..\STM32F103C8\MCAL\GPIO;..\STM32F103C8\Library;..\STM32F103C8\Library\MCU;..\STM32F103C8\Application;..\STM32F103C8\Library\Cortex_M3\Headers;..\STM32F103C8\MCAL\USART;..\STM32F103C8\MCAL\NVIC;..\STM32F103C8\Library\Bootloader
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\Build\STM32F103C8.sct
  group Source Files
    ../STM32F103C8/Application/: Application.c
    ../STM32F103C8/MCAL/GPIO/: GPIO_Program.c
    ../STM32F103C8/MCAL/RCC/: RCC_Program.c
    ../STM32F103C8/Library/Cortex_M3/: Startup.s System_Init.c
    ../STM32F103C8/MCAL/USART/: USART_Program.c
    ../STM32F103C8/MCAL/NVIC/: NVIC_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
